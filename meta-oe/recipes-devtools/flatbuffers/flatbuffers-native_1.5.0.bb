require flatbuffers.inc

inherit cmake native

CXXFLAGS += "--std=c++11"
